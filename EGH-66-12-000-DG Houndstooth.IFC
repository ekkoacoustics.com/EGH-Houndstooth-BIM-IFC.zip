Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Houndstooth\EGH-66-12-000-DG Houndstooth.IFC
Time: 2024-11-05T11:47:35+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 3.6807380151110962; Volume Measure: 0.0036807380151111; Area Measure: 1.5306478210698147

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 3.6807380151110962; Volume Measure: 0.0036807380151111; Area Measure: 1.5306478210698147

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 3.6807380151110962; Volume Measure: 0.0036807380151111; Area Measure: 1.5306478210698147

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGH-66-12-000-DG Houndstooth | PSet_Mass_Property - Mass Measure: 3.6807380151110962; Volume Measure: 0.0036807380151111; Area Measure: 1.5306478210698147
EGH-66-12-000-DG Houndstooth | SOLIDWORKS Custom Properties - Description: HOUNDSTOOTH; PartNo: EGH-66-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
