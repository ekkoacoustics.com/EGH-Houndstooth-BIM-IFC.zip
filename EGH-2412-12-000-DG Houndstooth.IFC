Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Houndstooth\EGH-2412-12-000-DG Houndstooth.IFC
Time: 2024-11-05T11:46:13+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 29.4459041208887875; Volume Measure: 0.0294459041208890; Area Measure: 12.1514633210776406

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 29.4459041208887875; Volume Measure: 0.0294459041208890; Area Measure: 12.1514633210776406

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 29.4459041208887875; Volume Measure: 0.0294459041208890; Area Measure: 12.1514633210776406

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGH-2412-12-000-DG Houndstooth | PSet_Mass_Property - Mass Measure: 29.4459041208887875; Volume Measure: 0.0294459041208890; Area Measure: 12.1514633210776406
EGH-2412-12-000-DG Houndstooth | SOLIDWORKS Custom Properties - Description: HOUNDSTOOTH; PartNo: EGH-2412-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
