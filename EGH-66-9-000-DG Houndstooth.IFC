Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Houndstooth\EGH-66-9-000-DG Houndstooth.IFC
Time: 2024-11-05T11:48:07+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 2.6007380151110957; Volume Measure: 0.0026007380151111; Area Measure: 1.5234478210698148

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 2.6007380151110957; Volume Measure: 0.0026007380151111; Area Measure: 1.5234478210698148

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 2.6007380151110957; Volume Measure: 0.0026007380151111; Area Measure: 1.5234478210698148

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGH-66-9-000-DG Houndstooth | PSet_Mass_Property - Mass Measure: 2.6007380151110957; Volume Measure: 0.0026007380151111; Area Measure: 1.5234478210698148
EGH-66-9-000-DG Houndstooth | SOLIDWORKS Custom Properties - Description: HOUNDSTOOTH; PartNo: EGH-66-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
