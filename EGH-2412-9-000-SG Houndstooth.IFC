Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Houndstooth\EGH-2412-9-000-SG Houndstooth.IFC
Time: 2024-11-05T11:46:41+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 24.9274565823219199; Volume Measure: 0.0249274565823231; Area Measure: 11.8416596450320242

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 24.9274565823219199; Volume Measure: 0.0249274565823231; Area Measure: 11.8416596450320242

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 24.9274565823219199; Volume Measure: 0.0249274565823231; Area Measure: 11.8416596450320242

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGH-2412-9-000-SG Houndstooth | PSet_Mass_Property - Mass Measure: 24.9274565823219199; Volume Measure: 0.0249274565823231; Area Measure: 11.8416596450320242
EGH-2412-9-000-SG Houndstooth | SOLIDWORKS Custom Properties - Description: HOUNDSTOOTH; PartNo: EGH-2412-9-000-SG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
